R11 A R11_2 10k

C9 R11_2 Q4B 0.01u

C11 Q4B C11_2 0.01u

R18 C11_2 B 220k

Q4 Q4C Q4B Q4E MMBT3904
R12 Vin Q4B 150k

R14 Vin Q4C 2.2k

R13 Q4B 0 100k

R15 Q4E 0 2.2k

R16 Q4E R16_2 1k

C10 R16_2 0 10u

C12 Q4C 0 0.01u
C13 R17_2 0 0.01u

R17 Q4C R17_2 10k
