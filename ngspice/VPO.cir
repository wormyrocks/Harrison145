.title VPO netlist

***** NETLIST *****

R22 Vin F 22k
C18 Vin Q7B 1u
R25 Q7B 0 10k
R24 Vin Q7B 3.3k
R23 Q6B Q7B 100k
C17 Q6B PITCH_ANT 10p

* PNP order:
* Collector -> Base   -> Emitter
* (No arrow -> Middle -> Arrow )
Q6 Q6C Q6B F MMBT3906
Q7 PITCH_ANT Q7B F MMBT3906

* Oscillator

* Coilcraft model
X2 PITCH_ANT 0 1812FS105_imp

*L2 PITCH_ANT L2_DCR 1m
*R_L2DC L2_DCR 0 19.5

C16 Q6C 0 150p

* TODO: parameterize this
C14 PITCH_ANT 0 5p

* JFET
J5 Vin J5G B J2N5484
R20 Vin J5G 4.7Meg
C15 PITCH_ANT J5G 10p
R21 J5G 0 2.7Meg
R19 B 0 2.2k

***** END NETLIST *****
