Q14 Q14C Q14B Q14E MMBT3904

C35 E Q14B 0.1u

R44 Vin Q14B 100k

R43 Vin Q14C 680

R45 Q14B 0 33k

R47 Q14E R47_2 33

C39 R47_2 0 220u

R46 Q14E 0 220

C36 Q14C 0 0.47u

C38 Q14C C38_2 10u

C37 C38_2 C37_2 10u

R42 C38_2 0 1Meg

Q15 V9V Q15B Q15E MMBT3904
Q16 0 Q16B Q16E MMBT3906

R49 Vin Q15B 22k
R50 Q15B C37_2 4.7k
R51 C37_2 Q16B 4.7k
R52 Q16B 0 22k
R53 Q15E R53_2 10
R54 Q16E R53_2 10

C40 R53_2 LINE_OUT 10u

R55 LINE_OUT 0 100k
