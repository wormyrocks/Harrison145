.title FPO netlist

***** NETLIST *****

R2 Vin Q1E 22k
C1 Vin Q1B 1u
R3 Q1B 0 10k
R1 Vin Q1B 3.3k

* TODO: double check value of R4
* What happens when we disconnect F?

R4 Q1B Q2B 100k
R10 Q1E R10_2 1Meg
C8 R10_2 F 0.01u
C4 Q2B Q1C 10p

* PNP order:
* Collector -> Base   -> Emitter
* (No arrow -> Middle -> Arrow )
Q1 Q1C Q1B Q1E MMBT3906
Q2 0 Q2B Q1E MMBT3906

* Oscillator

* Coilcraft model
X1 Q1C 0 1812FS105_imp

*L1 Q1C L1_DCR 1m
*R_L1DC L1_DCR 0 19.5

C6 Q1C 0 150p

* Varicap

C7 Q1C 0 3.5p

* Potentiometer

R48 Vin R48_2 100k
RV2_1 R48_2 RV2_Wiper 5K
RV2_2 RV2_Wiper 0 5K
*ARV2 0 RV2_Wiper R48_2 APot

* Diode-y part
C3 Q1C C3_2 100p
R9 C3_2 0 1Meg
D1 C3_2 D1_2 SM4001
D2 0 D1_2 SM4001
R8 D1_2 RV2_Wiper 1Meg
C2 RV2_Wiper 0 1u

* JFET
J3 Vin J3G A J2N5484
R5 Vin J3G 4.7Meg
R6 J3G 0 2.7Meg
C5 Q1C J3G 10p
R7 A 0 2.2k

***** END NETLIST *****
